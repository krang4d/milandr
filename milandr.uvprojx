# Keil uVision project milandr.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Milandr.MDR1986BExx.1.4.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: milandr +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: .\emdr1986x-std-per-lib\MDR32F9Qx_StdPeriph_Driver\inc;.\emdr1986x-std-per-lib\CMSIS\CM3\CoreSupport;.\emdr1986x-std-per-lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup;.\emdr1986x-std-per-lib\Config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MainCode
    ./: main.c MDR32F9Qx_board.h
  group Module
    ./Module/: init_ports.c init_spi.c init_uart.c init_CPU.c init_timer.c init_interrupt.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1, Drivers:SSP 1.3.1, Drivers:TIMER 1.3.1, Drivers:UART 1.3.1
